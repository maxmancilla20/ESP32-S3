## esp_IoT/main/Kconfig.projbuild
```kconfig
menu "Example configuration"
    rsource "../esp-idf-lib/devtools/Kconfig.i2c"
endmenu
```
